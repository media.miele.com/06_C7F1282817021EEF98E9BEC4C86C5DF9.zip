Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: de18684f-a8f7-48eb-8e50-7d5e573e29d6, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-12T11:26:21+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11819940_D_TCR790WP_LW:12CR7902_D_11819940_TCR790WP_LW, (2)
In: Default
Type - Material: z_Miele_Design_Steel_Chrom, z_Miele_Design_Orange, <Unnamed>, z_Miele_Design_Glass, z_Miele_Design_OBSW, z_Miele_Design_Alusilver, z_Miele_Design_Powder Coat_Lotus White, z_Miele_Design_Glass Black, z_Miele_Connection_Water_OUT, z_Miele_Connection_Electric, z_Miele_Design_Zinc_Steel
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 596 mm; Height: 850 mm; Depth: 636 mm
Classification: E1010610 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 12CR7902_D_11819940_TCR790WP_LW; sets with these values: 2

# IfcDistributionPort, Port_360237_1
Description: Flow; FlowDirection: SOURCEANDSINK
